## config/boards/shields/feather_compat/Kconfig.shield
```kconfig
config SHIELD_FEATHER_COMPAT
    bool "Feather nRF52840 Pro Micro compatibility shim"
```
